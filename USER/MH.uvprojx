# Keil uVision project MH.uvprojx, settings and files
target MH (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MH +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\LCD;..\HARDWARE\RTC;..\HARDWARE\RTC;..\HARDWARE\WKUP;..\HARDWARE\ADC;..\HARDWARE\DAC;..\HARDWARE\DMA;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\HARDWARE\SPI;..\HARDWARE\STMFLASH;..\HARDWARE\REMOTE;..\HARDWARE\DS18B20;..\HARDWARE\SD;..\FATFS\exfuns;..\FATFS\src;..\USMART;..\FATFS\src\option;..\HARDWARE\SDIO;..\HARDWARE\W25QXX;..\HARDWARE\SYSTICK;..\SYSTEM\mbuf
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000200 size 0xfe00
  group USER
    ./: MH-Struct.h main.c stm32f10x_it.c system_stm32f10x.c 485Server.c Client.c DataFile.c SMSAlarm.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/SYSTICK/: SysTick.c
    ../HARDWARE/SPI/: SPI_Flash.c
    ../HARDWARE/STMFLASH/: stmflash.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/mbuf/: mbuf.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_dma.c stm32f10x_sdio.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_flash.c
  group FATFS
    ../FATFS/src/: ffconf.h diskio.c ff.c ffsystem.c ffunicode.c
